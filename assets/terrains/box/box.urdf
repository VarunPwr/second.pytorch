Commit message: change terrains

File: assets/terrains/box/box.urdf (robot description, URDF)
Before this commit: robot box_terrain, 1 links, 0 joints
Links:
- link box_terrain: geometry collision box size=0.06 0.06 0.06; collision box size=0.06 0.06 0.06
