Commit message: new jumping

File: assets/terrains/jumping_barrier/jumping_barrier.urdf (robot description, URDF)
Before this commit: robot stairs_terrain, 1 links, 0 joints
Links:
- link stairs_terrain: geometry collision box size=6 0.2 0.8; collision box size=6 0.2 0.8
