Commit message: robot origin & bench

File: assets/terrains/upladder/upladder.urdf (robot description, URDF)
Before this commit: robot ladder_terrain, 1 links, 0 joints
Links:
- link ladder_terrain: geometry collision box size=2 0.05 1.0; collision box size=2 0.05 1.0
